options:
  parameters:
    author: ZeeTwii
    description: Sample ADS-B generation flowgraph
    generate_options: qt_gui
    id: adsbTest
    output_language: python
    title: ADS-B Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: adsb_adsbGen_0
  id: adsb_adsbGen
  parameters:
    portNum: '7331'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 1.09e9
    fftsize: '1024'
    showrf: 'True'
    type: float
  states: {}

connections:
- [adsb_adsbGen_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
